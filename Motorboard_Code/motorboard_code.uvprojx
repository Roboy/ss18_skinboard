# Keil uVision project motorboard_code.uvprojx, settings and files
target TLE9879 EvalKit (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TLE9879QXA40 Infineon
  pack: Infineon.TLE987x_DFP.1.3.2
  cpu: IROM(0x11000000,0x1EFFC) IROM2(0x1101EFFC,4) IRAM(0x18000000,0x1800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: motorboard_code
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: .\emo;.\app
  memory RVCT4: ROM 0x11000000 size 0x1effc
  memory RVCT5: ROM 0x1101effc size 0x4
  memory RVCT9: RAM 0x18000000 size 0x1800
  group app
    ./app/: Main.c
  group emo
    ./emo/: Emo.c EmoCcu.c EmoCcu_Cfg.c
software components: CMSIS:CORE 5.1.2, Device:ConfigWizard 1.8.6, Device:SDK:ADC1 0.1.6, Device:SDK:ADC2 0.1.6, Device:SDK:BDRV 0.3.7, Device:SDK:BOOTROM 0.2.1, Device:SDK:CCU6 0.2.3, Device:SDK:DMA 0.1.3, Device:SDK:GPT12E 0.1.4, Device:SDK:INT 0.1.4, Device:SDK:ISR 0.2.0, Device:SDK:PORT 0.5.2, Device:SDK:SCU 0.3.1, Device:SDK:SSC 0.1.2, Device:SDK:TIMER2x 0.1.4, Device:SDK:WDT1 0.2.6, Device:Startup 1.0.0
